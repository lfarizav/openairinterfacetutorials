options:
  parameters:
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: down_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '3'
    stop: '76'
    value: '65'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '44100'
    step: 100e3
    stop: 10e6
    value: 3e6
  states: {}
- name: tuner
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 88.1e6
    step: 200e3
    stop: 150e6
    value: 97.9e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: vol
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: down_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '24000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume/100
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: 100e3
    decim: int(samp_rate/down_rate)
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_KAISER
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuner
    fftsize: '1024'
    name: '"Spectrum RX"'
    plotconst: 'False'
    rate: '15'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: down_rate
    fc: '0'
    fftsize: '1024'
    name: '"Spectrum RX decoded"'
    plotconst: 'False'
    rate: '15'
    showrf: 'True'
    type: float
    wintype: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '24'
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate
    center_freq0: tuner
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rf_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', qtgui_sink_x_0_0_0_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_2, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_2, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0_0_0, '0']

metadata:
  file_format: 1
